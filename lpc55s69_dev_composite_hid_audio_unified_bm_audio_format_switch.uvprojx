# Keil uVision project lpc55s69_dev_composite_hid_audio_unified_bm_audio_format_switch.uvprojx, settings and files
target lpc55s69_dev_composite_hid_audio_unified_bm_audio_format_switch debug (6180000::V6.18::ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.15.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: lpc55s69_dev_composite_hid_audio_unified_bm_audio_format_switch.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _DEBUG=1, DEBUG, CPU_LPC55S69JBD100_cm33_core0=1, USB_STACK_BM, USB_STACK_USE_DEDICATED_RAM=1, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8904_ENABLE, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK
  c misc: -mno-unaligned-access -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: board;source;CMSIS;LPC55S69/drivers;codec;codec/port;codec/port/wm8904;component/i2c;component/lists;component/osa;component/uart;device;drivers;usb/device/class;usb/device/class/audio;usb/device/class/hid;usb/device/include;usb/device/source;usb/device/source/lpcip3511;usb/include;usb/phy;utilities
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69/arm/LPC55S69_cm33_core0_flash.scf
  link misc: LPC55S69/arm/keil_lib_power_cm33_core0.lib --remove --entry=Reset_Handler --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x1000" --predefine="-D__usb_use_usbram__=1"
LPC55S69/arm/keil_lib_power_cm33_core0.lib
LPC55S69/arm/keil_lib_power_cm33_core0_disable_short_enum_wchar.lib
LPC55S69/arm/keil_lib_power_cm33_core1_disable_short_enum_wchar.lib
--remove
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group codec
    codec/: fsl_codec_common.c fsl_codec_common.h fsl_codec_i2c.c fsl_codec_i2c.h fsl_wm8904.c fsl_wm8904.h
  group codec/port
    codec/port/: fsl_codec_adapter.h
  group codec/port/wm8904
    codec/port/wm8904/: fsl_codec_wm8904_adapter.c fsl_codec_wm8904_adapter.h
  group component/i2c
    component/i2c/: fsl_adapter_flexcomm_i2c.c fsl_adapter_i2c.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/osa
    component/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group component/uart
    component/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group device
    device/: fsl_device_registers.h LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_ctimer.c fsl_ctimer.h fsl_dma.c fsl_dma.h fsl_flexcomm.c fsl_flexcomm.h fsl_gint.c fsl_gint.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2s.c fsl_i2s.h fsl_i2s_dma.c fsl_i2s_dma.h fsl_iocon.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group LPC55S69/drivers
    LPC55S69/drivers/: fsl_power.c fsl_power.h
  group source
    source/: audio_unified.c audio_unified.h composite.c composite.h hid_keyboard.c hid_keyboard.h usb_audio_config.h usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h
  group startup
    startup/: startup_LPC55S69_cm33_core0.S
  group usb
    usb/: ChangeLogKSDK.txt
  group usb/device/class/audio
    usb/device/class/audio/: usb_device_audio.c usb_device_audio.h
  group usb/device/class/hid
    usb/device/class/hid/: usb_device_hid.c usb_device_hid.h
  group usb/device/class
    usb/device/class/: usb_device_class.c usb_device_class.h
  group usb/device/include
    usb/device/include/: usb_device.h
  group usb/device/source/lpcip3511
    usb/device/source/lpcip3511/: usb_device_lpcip3511.c usb_device_lpcip3511.h
  group usb/device/source
    usb/device/source/: usb_device_ch9.c usb_device_ch9.h usb_device_dci.c usb_device_dci.h
  group usb/include
    usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/phy
    usb/phy/: usb_phy.c usb_phy.h
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
target lpc55s69_dev_composite_hid_audio_unified_bm_audio_format_switch release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.15.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _DEBUG=0, NDEBUG, CPU_LPC55S69JBD100_cm33_core0=1, USB_STACK_BM, USB_STACK_USE_DEDICATED_RAM=1, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8904_ENABLE, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SDK_DEBUGCONSOLE=1, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69/arm/LPC55S69_cm33_core0_flash.scf
  link misc: as above
